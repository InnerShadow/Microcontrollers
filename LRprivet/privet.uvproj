# Keil uVision project privet.uvproj, settings and files
target Privetik (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: privet
  c flags: Optimize=8 SizeSpeed=1
  group C Group
    ./: HELLO.C Privet.c HELLOn.C
  group Doc
    ./: scr.ini
target Hello (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: privet
  c flags: Optimize=8 SizeSpeed=1
target Privet (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: privet
  c flags: Optimize=8 SizeSpeed=1
