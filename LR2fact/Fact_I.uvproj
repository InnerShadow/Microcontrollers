# Keil uVision project Fact_I.uvproj, settings and files
target Factor1 (MCS-51)
  device: 8031AH Intel
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: factor
  c flags: Optimize=8 SizeSpeed=1
  group Asm Group
    ./: STARTUP.A51
  group C Group
    ./: Fact_i.c
  group Document
    ./: Otchet.txt
