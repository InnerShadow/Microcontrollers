# Keil uVision project Aprivet.uvproj, settings and files
target QuikSt (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Aprivet
  c flags: Optimize=8 SizeSpeed=1
  group ASM Group
    ./: A0main.a51 A1io.a51 A2pc.a51 a4.a51
