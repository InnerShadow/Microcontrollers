# Keil uVision project mashin1.uvproj, settings and files
target Mash1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: mashin1
  c flags: Optimize=8 SizeSpeed=1
  group Document
    ./: Otchet0.txt
