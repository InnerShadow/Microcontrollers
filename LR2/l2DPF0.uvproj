# Keil uVision project l2DPF0.uvproj, settings and files
target DPFst (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: l2DPF0
  group C Group
    ./: dpf0.c main0.c main1.c dpf1.c
  group H files
    ./: dpf0.h dpf1.h
  group Document
    ./: scrpt2.ini Otch2lr.txt
target DPFopt (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: l2DPF0
  c flags: Optimize=8 SizeSpeed=1
